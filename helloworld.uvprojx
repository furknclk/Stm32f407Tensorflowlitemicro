# Keil uVision project helloworld.uvprojx, settings and files
target helloworld (6120000::V6.12::.\ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Human_detection
  c flags: Optim=7 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F4XX,HSE_VALUE=8000000
  c include: .;third_party/gemmlowp;third_party/flatbuffers/include;third_party/ruy;third_party/kissfft
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    tensorflow/core/public/: version.h
    tensorflow/lite/c/: builtin_op_data.h common.c common.h
    tensorflow/lite/core/api/: error_reporter.cc error_reporter.h flatbuffer_conversions.cc flatbuffer_conversions.h op_resolver.cc op_resolver.h profiler.h tensor_utils.cc tensor_utils.h
    tensorflow/lite/kernels/internal/: common.h compatibility.h cppmath.h max.h min.h portable_tensor.h quantization_util.cc quantization_util.h strided_slice_logic.h tensor_ctypes.h types.h
    tensorflow/lite/kernels/internal/optimized/: neon_check.h
    tensorflow/lite/kernels/internal/reference/: add.h arg_min_max.h binary_function.h ceil.h comparisons.h concatenation.h conv.h depthwiseconv_float.h depthwiseconv_uint8.h dequantize.h floor.h fully_connected.h hard_swish.h l2normalization.h logistic.h maximum_minimum.h mul.h neg.h pad.h pooling.h prelu.h process_broadcast_shapes.h quantize.h reduce.h requantize.h resize_nearest_neighbor.h round.h softmax.h strided_slice.h sub.h tanh.h
    tensorflow/lite/kernels/internal/reference/integer_ops/: add.h conv.h depthwise_conv.h fully_connected.h l2normalization.h logistic.h mean.h mul.h pooling.h tanh.h
    tensorflow/lite/kernels/: kernel_util.cc kernel_util.h op_macros.h padding.h
    tensorflow/lite/micro/: all_ops_resolver.cc all_ops_resolver.h compatibility.h debug_log.cc debug_log.h memory_helpers.cc memory_helpers.h micro_allocator.cc micro_allocator.h micro_error_reporter.cc micro_error_reporter.h micro_interpreter.cc micro_interpreter.h micro_mutable_op_resolver.h micro_op_resolver.h micro_profiler.cc micro_profiler.h micro_string.cc micro_string.h micro_time.cc micro_time.h micro_utils.cc micro_utils.h recording_micro_allocator.cc recording_micro_allocator.h recording_micro_interpreter.h recording_simple_memory_allocator.cc recording_simple_memory_allocator.h simple_memory_allocator.cc simple_memory_allocator.h test_helpers.cc test_helpers.h
    tensorflow/lite/micro/benchmarks/: keyword_scrambled_model_data.cc keyword_scrambled_model_data.h
    tensorflow/lite/micro/kernels/: activation_utils.h activations.cc add.cc arg_min_max.cc ceil.cc circular_buffer.cc comparisons.cc concatenation.cc conv.cc depthwise_conv.cc dequantize.cc elementwise.cc ethosu.cc floor.cc fully_connected.cc hard_swish.cc kernel_runner.cc kernel_runner.h kernel_util.cc kernel_util.h l2norm.cc logical.cc logistic.cc maximum_minimum.cc micro_ops.h micro_utils.h mul.cc neg.cc pack.cc pad.cc pooling.cc prelu.cc quantize.cc reduce.cc reshape.cc resize_nearest_neighbor.cc round.cc softmax.cc split.cc split_v.cc strided_slice.cc sub.cc svdf.cc tanh.cc unpack.cc
    tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc greedy_memory_planner.h linear_memory_planner.cc linear_memory_planner.h memory_planner.h
    tensorflow/lite/micro/testing/: micro_test.h test_conv_model.cc test_conv_model.h test_utils.cc test_utils.h
    tensorflow/lite/: portable_type_to_tflitetype.h version.h
    tensorflow/lite/schema/: schema_generated.h schema_utils.cc schema_utils.h
    third_party/flatbuffers/: LICENSE.txt
    third_party/flatbuffers/include/flatbuffers/: base.h flatbuffers.h stl_emulation.h
    third_party/gemmlowp/: LICENSE
    third_party/gemmlowp/fixedpoint/: fixedpoint.h fixedpoint_neon.h fixedpoint_sse.h
    third_party/gemmlowp/internal/: detect_platform.h
    third_party/ruy/ruy/profiler/: instrumentation.h
    ./: Main.cpp
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 2.6.2
